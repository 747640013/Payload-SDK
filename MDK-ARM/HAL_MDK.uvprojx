# Keil uVision project HAL_MDK.uvprojx, settings and files
target HAL_MDK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HAL_MDK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,SYSTEM_ARCH_RTOS=1
  c misc: --diag_suppress=188,177,550,940,66,546 --gnu   -DUSE_USB_HOST_UART=1 --split_sections
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\MiddleWare\FreeRTOS\Source\include;..\MiddleWare\FreeRTOS\Source\CMSIS_RTOS;..\Middleware\FreeRTOS\Source\portable\RVDS\ARM_CM4F;../Bsp;../LIb/include;..\Module_Sample;../Common/osal;../Usb_host/App;../Usb_host/Target;../Hal;../STM32_USB_Host_Library/Core/Inc;../STM32_USB_Host_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Common/osal/: osal.c
    ../Core/Src/: application.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/Api_sample
    ../Module_sample/utils/: cJSON.c dji_config_manager.c util_buffer.c util_file.c util_link_list.c util_md5.c util_misc.c util_time.c
    ../Module_sample/camera_manager/: test_camera_manager.c
    ../Module_sample/data_transmission/: test_data_transmission.c
    ../Module_sample/fc_subscription/: test_fc_subscription.c
    ../Module_sample/flight_control/: test_flight_control.c
    ../Module_sample/gimbal_manager/: test_gimbal_manager.c
    ../Module_sample/hms/: test_hms.c
    ../Module_sample/camera_emu/: test_payload_cam_emu_base.c
    ../Module_sample/payload_collaboration/: test_payload_collaboration.c
    ../Module_sample/gimbal_emu/: test_payload_gimbal_emu.c
    ../Module_sample/xport/: test_payload_xport.c
    ../Module_sample/positioning/: test_positioning.c
    ../Module_sample/power_management/: test_power_management.c
    ../Module_sample/time_sync/: test_time_sync.c
    ../Module_sample/upgrade/: test_upgrade.c test_upgrade_common_file_transfer.c test_upgrade_platform_opt.c
    ../Module_sample/waypoint_v2/: test_waypoint_v2.c
    ../Module_sample/waypoint_v3/: test_waypoint_v3.c
    ../Module_sample/widget/: test_widget.c test_widget_speaker.c file_binary_array_list_en.c
    ../Module_sample/widget_interaction_test/: test_widget_interaction.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middleware/FreeRTOS/port
    ../MiddleWare/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../MiddleWare/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../MiddleWare/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/src
    ../MiddleWare/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Bsp
    ../Bsp/: uart.c dji_ringbuffer.c apply_high_power.c button.c flash_if.c freertos.c pps.c upgrade_platform_opt_stm32.c led.c
    ../STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
    ../STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Lib
    ../LIb/: libpayload.lib
  group Hal
    ../Hal/: hal_i2c.c hal_uart.c
  group Usb_host
    ../Usb_host/App/: usb_host.c
    ../Usb_host/Target/: usbh_conf.c
software components: CMSIS:CORE 4.3.0
